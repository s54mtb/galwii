# Keil uVision project galwii.uvprojx, settings and files
target GalWii (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: galwii
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./: galwii.c LCD_4bit.c kalman.c pwm.c adc.c
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
    RTE/Device/STM32F103RB/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
  group ::Drivers
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: USBD_STM32F10x.c
  group ::USB
    C:/Keil/ARM/PACK/Keil/MDK-Middleware/5.1.5/USB/Lib/ARM/: USB_CM3_L.lib
    RTE/USB/: USBD_Config_0.c USBD_Config_CDC_0.h
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, USB:CORE 5.0.5, USB:Device 5.0.5, USB:Device:CDC 5.0.5, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Drivers:USB Device:Full-speed 1.0.0
